# Keil uVision project F427IIH6_CAN.uvprojx, settings and files
target F427IIH6_CAN (6240000::V6.24::ARMCLANG)
  device: STM32F427IIHx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.3.1.1
  cpu: IRAM(0x20000000-0x2002FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x81FFFFF) CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: F427IIH6_CAN +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=6 v6LangP=6 wLevel=3
  c define: USE_HAL_DRIVER,STM32F427xx
  c include: ../mcu_bsp/ctrl;../mcu_bsp/proto;../Core/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Drivers/CMSIS/Include;../Task/Inc;../Device/Inc;../mcu_bsp/can;../mcu_bsp/Motor;../mcu_bsp/button;../mcu_bsp/key;../mcu_bsp/protocol;../mcu_bsp/protocol_calibration;../mcu_bsp/uart;../mcu_bsp/log;../mcu_bsp/oled;../Middlewares/Third_Party/FreeRTOS/Source/include;../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS;../Middlewares/Third_Party/FreeRTOS/Source/portable/GCC/ARM_CM4F;../Middlewares/Third_Party/FatFs/src;../Middlewares/Third_Party/FatFs/src/option;../mcu_bsp/sd;../mcu_bsp/fs;../mcu_bsp/version;../mcu_bsp/sys_status;../mcu_bsp/cli
  asm include: ../Drivers/CMSIS/Include
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Application/MDK-ARM
    ./: startup_stm32f427xx.s
  group Application/User/Core
    ../Core/Src/: maincpp.cpp main.c gpio.c freertos.c can.c dma.c tim.c usart.c stm32f4xx_it.c stm32f4xx_hal_msp.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_ll_sdmmc.c stm32f4xx_hal_sd.c stm32f4xx_hal_can.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f4xx.c
  group DEVICE
    ../Device/Src/: remote_control.c CyberGear.c servo.cpp control.cpp
  group Task
    ../Task/Src/: SdCard_Task.c CAN_Task.c Control_Task.c MotorTest_Task.c J8108_Task.c Led_Task.c Oled_Task.c CmdRx_Task.c Monitor_Task.c
  group BSP
    ../mcu_bsp/cli/: sd_cli.c
    ../mcu_bsp/sys_status/: sys_status.c fault_log.c
    ../mcu_bsp/fs/: sd_fs.c sd_diskio.c
    ../mcu_bsp/sd/: sd_sdio.c
    ../mcu_bsp/Motor/: dm_j4310.c motor_8108.c c620.c
    ../mcu_bsp/proto/: proto_tx.c
    ../mcu_bsp/ctrl/: ctrl_core.c
    ../mcu_bsp/key/: bsp_key.c key_core.c
    ../mcu_bsp/can/: bsp_can.c
    ../mcu_bsp/uart/: bsp_usart.c uart10_def.c
    ../mcu_bsp/log/: bsp_log.c
    ../mcu_bsp/oled/: OLED.c OLED_Data.c
    ../mcu_bsp/protocol/: CRSF.c
    ../mcu_bsp/protocol_calibration/: crc8.c
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/GCC/ARM_CM4F/: port.c
  group Middlewares/FatFs
    ../Middlewares/Third_Party/FatFs/src/: ff.c
    ../Middlewares/Third_Party/FatFs/src/option/: ccsbcs.c
software components: CMSIS:CORE 6.1.0
